## boards/shields/dictatel/Kconfig.defconfig
```kconfig
if SHIELD_ADEPTBLE

config ZMK_KEYBOARD_NAME
    default "dictatel"

endif

config SPI
	default y
```
